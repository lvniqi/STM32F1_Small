# IAR project Project.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: UserCode\; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\LNQ\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/inc
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group CMSIS/src
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    UserCode/: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group LNQ/AD
    ../../Libraries/LNQ/src/: AD.c
    ../../Libraries/LNQ/inc/: AD.h
  group LNQ/common
    ../../Libraries/LNQ/src/: common.c
    ../../Libraries/LNQ/inc/: common.h pt.h Sequeue.h
  group LNQ/DA
    ../../Libraries/LNQ/src/: DA.c
    ../../Libraries/LNQ/inc/: DA.h
  group LNQ/EXTI
    ../../Libraries/LNQ/src/: exti.c
    ../../Libraries/LNQ/inc/: exti.h
  group LNQ/FPGA
    ../../Libraries/LNQ/src/: FPGA.c
    ../../Libraries/LNQ/inc/: FPGA.h
  group LNQ/GPIO
    ../../Libraries/LNQ/inc/: GPIO.h
  group LNQ/LCD
    ../../Libraries/LNQ/inc/: FONT.h LCD.h
    ../../Libraries/LNQ/src/: LCD.c
  group LNQ/SPI
    ../../Libraries/LNQ/src/: NRF2401.c SPI.c SPI_FLASH.c
    ../../Libraries/LNQ/inc/: NRF2401.h SPI.h SPI_FLASH.h
  group LNQ/UART
    ../../Libraries/LNQ/src/: USART.c
    ../../Libraries/LNQ/inc/: USART.h
  group StdPeriph_Driver/inc
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group StdPeriph_Driver/src
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    UserCode/: DAC_CODE.c DAC_CODE.h main.c stm32f10x_it.c
